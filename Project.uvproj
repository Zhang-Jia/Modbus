# Keil uVision project Project.uvproj, settings and files
target STM3210E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\scr;.\scr\Libraries;.\scr\Libraries\CMSIS;.\scr\Libraries\Startup;.\scr\Libraries\STM32F10x_StdPeriph_Driver\inc;.\scr\modbus\include;.\scr\modbus\port;.\scr\modbus\ascii;.\scr\modbus\functions;.\scr\modbus\rtu;.\scr\modbus\tcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./scr/Libraries/Startup/: startup_stm32f10x_hd.s system_stm32f10x.c
  group CMSIS
    ./scr/Libraries/CMSIS/: core_cm3.c
  group StdPeriph_Driver
    ./scr/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group Modbus
    ./scr/modbus/ascii/: mbascii.c
    ./scr/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./scr/modbus/rtu/: mbcrc.c mbrtu.c
    ./scr/modbus/tcp/: mbtcp.c
    ./scr/modbus/: mb.c
  group ModbusPort
    ./scr/modbus/include/: mbconfig.h
    ./scr/modbus/port/: portevent.c portserial.c porttimer.c port.h
  group User
    ./scr/: stm32f10x_it.c stm32f10x_conf.h main.c modbusCB.c
